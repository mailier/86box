# Keil uVision project 86box_temperature.uvproj, settings and files
target <86box_temperature> (MCS-51)
  device: SC95F8617 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: 86box_temperature +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FWLib\SC95F8x1x_Lib\inc;..\User
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c EC06_key.c interface.c BM8563.c NST1001.c operation.c
  group FWLib
    ../FWLib/SC95F8x1x_Lib/src/: sc95f8x1x_ddic.c sc95f8x1x_gpio.c sc95f8x1x_int.c sc95f8x1x_option.c sc95f8x1x_timer2.c sc95f8x1x_iap.c
  group Startup
    ./: STARTUP.A51
