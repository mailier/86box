# Keil uVision project project name.uvproj, settings and files
target <project name> (MCS-51)
  device: SC92F8003 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0xFF) CLOCK(16000000)
  output: project name +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FWLib\SC95F8x1x_Lib\inc;..\User
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c
  group FWLib
    ../FWLib/SC95F8x1x_Lib/src/: sc95f8x1x_gpio.c sc95f8x1x_option.c
  group Startup
    ./: STARTUP.A51
